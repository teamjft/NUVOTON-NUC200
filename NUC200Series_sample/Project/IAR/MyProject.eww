<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MyProject.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>MyProject</name>
      <member>
        <project>MyProject</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MyProject</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


