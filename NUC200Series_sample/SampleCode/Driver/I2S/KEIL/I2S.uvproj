# Keil uVision project I2S.uvproj, settings and files
target I2S (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: I2S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=2
  c include: ..\..\..\..\libNUC200Series\CMSIS\CM0\DeviceSupport\Nuvoton\NUC200Series;..\..\..\..\libNUC200Series\CMSIS\CM0\CoreSupport;..\..\..\..\libNUC200Series\StdDriver\inc;..\..\..\..\LibNUC200Series\LearningBoard\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC200Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../LibNUC200Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/: system_NUC200Series.c
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/startup/arm/: startup_NUC200Series.s
  group Source files
    ../: main.c
  group Library files
    ../../../../LibNUC200Series/StdDriver/src/: retarget.c
    ../../../../LibNUC200Series/LearningBoard/src/: WAU8822.c
