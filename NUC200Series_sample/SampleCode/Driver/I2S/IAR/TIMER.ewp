# IAR project TIMER.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: M051 series Nuvoton M051 series (M052,M054,M058,M0516)
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; $PROJ_DIR$..\..\..\..\..\libM051Series\CMSIS\CM0\CoreSupport; $PROJ_DIR$..\..\..\..\..\libM051Series\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\LibM051Series\M051-LB_004_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TIMER.bin
  ILINK.IlinkOutputFile: TIMER.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: M0516 Nuvoton M0516
  ICCARM.CCOptLevel: 0
  group CMSIS Files
    ../../../../LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
  group Library Files
    ../../../../LibM051Series/StdDriver/src/: retarget.c
  group Source Files
    ../: main.c
