# IAR project I2S.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200 series Nuvoton NUC200 series (NUC200,NUC220,NUC230,NUC240)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\libNUC200Series\CMSIS\CM0\DeviceSupport\Nuvoton\NUC200Series; $PROJ_DIR$..\..\..\..\..\libNUC200Series\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\libNUC200Series\LearningBoard\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2S.bin
  ILINK.IlinkOutputFile: I2C.out
  ILINK.IlinkIcfFile: NUC200Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: I2C.bin
  group CMSIS Files
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/startup/iar/: startup_NUC200Series.s
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/: system_NUC200Series.c
  group Library Files
    ../../../../LibNUC200Series/StdDriver/src/: retarget.c
    ../../../../LibNUC200Series/LearningBoard/src/: WAU8822.c
  group Source Files
    ../: main.c
