# IAR project FMC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200 series Nuvoton NUC200 series (NUC200,NUC220,NUC230,NUC240)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\libNUC200Series\CMSIS\CM0\DeviceSupport\Nuvoton\NUC200Series; $PROJ_DIR$..\..\..\..\..\libNUC200Series\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC.bin
  ILINK.IlinkOutputFile: FMC.out
  ILINK.IlinkIcfFile: FMC.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\FMC_LD.bin,loaderImageBase,.bin_image,4; --image_input dummy.bin,loaderImageLimit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\libNUC200Series\CMSIS\CM0\DeviceSupport\Nuvoton\NUC200Series; ..\..\..\..\libNUC200Series\StdDriver\inc
  ICCARM.CCOptLevel: 0
  ILINK.IlinkExtraOptions: --image_input Debug\Exe\FMC_LD.bin,loaderImageBase,.bin_image,4; --image_input dummy.bin,loaderImageLimit,.bin_image,4
  group CMSIS Files
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/startup/iar/: startup_NUC200Series.s
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/: system_NUC200Series.c
  group Library Files
    ../../../../LibNUC200Series/StdDriver/src/: retarget.c
  group Source Files
    ../: main.c
