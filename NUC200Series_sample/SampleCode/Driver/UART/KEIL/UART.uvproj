# Keil uVision project UART.uvproj, settings and files
target UART (ARM-ADS)
  device: NUC200VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=2
  c include: ..\..\..\..\libNUC200Series\CMSIS\CM0\DeviceSupport\Nuvoton\NUC200Series;..\..\..\..\libNUC200Series\CMSIS\CM0\CoreSupport;..\..\..\..\libNUC200Series\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC200Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../LibNUC200Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/: system_NUC200Series.c
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/startup/arm/: startup_NUC200Series.s
  group Source files
    ../: main.c IrDA.c LIN_Master.c RS485.c
  group Library files
    ../../../../LibNUC200Series/StdDriver/src/: retarget.c
