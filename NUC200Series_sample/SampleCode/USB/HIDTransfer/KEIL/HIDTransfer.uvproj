# Keil uVision project HIDTransfer.uvproj, settings and files
target HIDTransfer (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: HIDTransfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=2
  c include: ..\..\..\..\libNUC200Series\CMSIS\CM0\DeviceSupport\Nuvoton\NUC200Series;..\..\..\..\libNUC200Series\CMSIS\CM0\CoreSupport;..\..\..\..\libNUC200Series\StdDriver\inc;..\..\..\..\LibNUC200Series\NUC200-LB_004_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC200Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../LibNUC200Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/: system_NUC200Series.c
    ../../../../LibNUC200Series/CMSIS/CM0/DeviceSupport/Nuvoton/NUC200Series/startup/arm/: startup_NUC200Series.s
  group Source files
    ../: main.c HIDTransfer_API.c HIDTransferSys.c
  group Library files
    ../../../../LibNUC200Series/StdDriver/src/: retarget.c USB.c
